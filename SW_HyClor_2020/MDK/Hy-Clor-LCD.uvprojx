# Keil uVision project Hy-Clor-LCD.uvprojx, settings and files
target Hy-Clor-LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Hy-Clor-LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: BOARD_SELECT  = BOARD_LCD_ENCODER
  c include: ..\SRC\mcu\common;..\SRC\driver\inc;..\SRC\hyclor\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_hc32l136.s
    ../SRC/mcu/common/: system_hc32l136.c
  group App
    ../SRC/hyclor/src/: ctrl.c keypad.c main.c mcu.c display.c st7565r.c app_uart.c crc32.c app_aes.c
  group Driver
    ../SRC/driver/src/: ddl.c flash.c gpio.c interrupts_hc32l136.c sysctrl.c bt.c adc.c timer3.c uart.c
software components: CMSIS:CORE 5.1.2
